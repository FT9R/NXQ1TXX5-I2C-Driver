<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NXQ1TXX5.ewp</path>
  </project>
  <batchBuild />
</workspace>
